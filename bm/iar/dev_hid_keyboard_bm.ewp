# IAR project dev_hid_keyboard_bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: $_KSDK_HOME_$/platform/osa/inc; $_KSDK_HOME_$/rtos; $_KSDK_HOME_$/platform/utilities/inc; $_KSDK_HOME_$/platform/CMSIS/Include; $_KSDK_HOME_$/platform/devices; $_KSDK_HOME_$/platform/devices/MK22F51212/include; $_KSDK_HOME_$/platform/devices/MK22F51212/startup; $_KSDK_HOME_$/examples/frdmk22f; $_KSDK_HOME_$/usb/adapter/sources; $_KSDK_HOME_$/usb/adapter/sources/sdk; $_KSDK_HOME_$/usb/usb_core/device/include/MK22F51212; $_KSDK_HOME_$/usb/usb_core/device/include; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/audio; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/cdc; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/common; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/composite; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/hid; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/include; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/include/config; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/msd; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/phdc; $_KSDK_HOME_$/usb/usb_core/device/sources/classes/video; $_KSDK_HOME_$/usb/usb_core/device/sources/controller/khci; $_KSDK_HOME_$/usb/usb_core/device/sources/controller; $_KSDK_HOME_$/usb/usb_core/hal; $_KSDK_HOME_$/usb/usb_core/host/include/MK22F51212; $_KSDK_HOME_$/usb/usb_core/host/include; $_KSDK_HOME_$/usb/usb_core/host/sources/classes/audio; $_KSDK_HOME_$/usb/usb_core/host/sources/classes/cdc; $_KSDK_HOME_$/usb/usb_core/host/sources/classes/hid; $_KSDK_HOME_$/usb/usb_core/host/sources/classes/hub; $_KSDK_HOME_$/usb/usb_core/host/sources/classes/msd; $_KSDK_HOME_$/usb/usb_core/host/sources/classes/phdc; $_KSDK_HOME_$/usb/usb_core/host/sources/classes/printer; $_KSDK_HOME_$/usb/usb_core/host/sources/controller/khci; $_KSDK_HOME_$/usb/usb_core/host/sources/controller; $_KSDK_HOME_$/usb/usb_core/include; $_KSDK_HOME_$/usb/usb_core/otg/sources/driver/khci; $_KSDK_HOME_$/usb/usb_core/otg/sources/driver/max3353/sdk; $_KSDK_HOME_$/usb/usb_core/otg/include; $_KSDK_HOME_$/usb/usb_core/otg/sources/otg; $_KSDK_HOME_$/platform/drivers/inc; $_KSDK_HOME_$/platform/drivers/src/uart; $_KSDK_HOME_$/platform/drivers/src/gpio; $_KSDK_HOME_$/platform/drivers/src/pit; $_KSDK_HOME_$/platform/drivers/src/edma; $_KSDK_HOME_$/platform/hal/inc; $_KSDK_HOME_$/platform/system/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: dev_hid_keyboard_bm.hex
  ILINK.IlinkOutputFile: dev_hid_keyboard_bm.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1; __stack_size__=0x1000; __heap_size__=0x0100
  ILINK.IlinkIcfFile: $_KSDK_HOME_$/platform/devices/MK22F51212/linker/iar/MK22FN512xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: $_KSDK_HOME_$/usb/usb_core/device/lib/bm/iar/MK22F51212/debug/libusbd_bm.a; $_KSDK_HOME_$/lib/ksdk_platform_lib/iar/K22F51212/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; CPU_MK22FN512VLH12; FRDM_K22F; FREEDOM
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: $_KSDK_HOME_$/usb/usb_core/device/lib/bm/iar/MK22F51212/release/libusbd_bm.a; $_KSDK_HOME_$/lib/ksdk_platform_lib/iar/K22F51212/release/libksdk_platform.a
  group board
    $_KSDK_HOME_$/examples/frdmk22f/: board.c board.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h
    ../../: hardware_init.c
  group sources
    ../../: keyboard.c keyboard.h usb_descriptor.c usb_descriptor.h
  group startup
    $_KSDK_HOME_$/platform/devices/: startup.c startup.h
    $_KSDK_HOME_$/platform/devices/MK22F51212/startup/iar/: startup_MK22F51212.s
    $_KSDK_HOME_$/platform/devices/MK22F51212/startup/: system_MK22F51212.c
  group utilities
    $_KSDK_HOME_$/platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    $_KSDK_HOME_$/platform/utilities/inc/: fsl_debug_console.h
